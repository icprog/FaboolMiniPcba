# Repository icprog/FaboolMiniPcba

File README.md:

# Fabool Laser Mini PCBA
- Product page: https://www.smartdiys.cc/fabool-laser-mini/
- Shop page: https://shop.smartdiys.cc/collections/desktop-laser-cutter-and-engraver
- Manual page: https://www.smartdiys.cc/manual/fabool-laser-mini/

## KiCad design LaserMiniBoard/LaserMiniBoard.kicad_pcb

Parts:
C1, C2, C9, C10: 0u22
C3, C4, C7, C8, C11, C12, C13, C14, C17, C18, C20, C21, C22, C23, C25, C26, C28, C33: 0u1
C5, C6: 100u
C15, C16: 2u2
C19, C24: 20p
C27, C30: 10p
C29: 10u
C31, C34: 10u
C32: 1u
D1: Y Stop
D2: Z Stop
D3: E1 Stop
D4: VIN
D5: USB
D6: 3.3V
J1: Y VREF
J2: X VREF
J3: LASER
J4: POWER IN
J6: PCB FAN
J7: BOX FAN
J8: JTAG
J9: X MOTOR
J10: Y1 MOTOR
J11: Y2 MOTOR
J12: USB
J13: X LIMIT
J14: Y LIMIT
J15: D SWITCH
L1: Ferrite bead
R1: 100k; 0603
R2, R4, R11, R12, R13, R14, R22, R23, R24, R25, R26, R32: 10k
R3: 100k
R5, R6: 0R
R7, R8, R9, R10: 0R1
R15, R16, R17, R31: 470R
R18, R19, R27: 4k7
R20: 2k7
R21: 100R
R28, R29: 22R
R30: 1K
SW1: SW_PUSH
SW2: SWITCH_INV
TR1: BSH105
U1: STM32F20XR; LQFP64
U2, U3: A4982SLPTR
U4: 74VHC1GT08
U5: 74HC1G00
U6: MCP44X1
U7: LD1117S33TR
X1: CRYSTAL_4PIN
X2: CRYSTAL

Connections:
+3.3V: C9.1, C10.1, C22.1, C23.1, C25.1, C28.1, C33.1, C34.1, D6.1 (A), J8.1 (VDD), L1.1, R1.1, R2.1, R3.1, R4.1, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.1, R19.1, R20.1, R22.1, R23.1, R24.1, R25.1, R26.1, SW2.1, U1.1 (VBAT), U1.19 (VDD_4), U1.32 (VDD_1), U1.48 (VDD_2), U1.64 (VDD_3), U2.5 (MS1), U2.6 (MS2), U2.10 (VDD), U3.5 (MS1), U3.6 (MS2), U3.10 (VDD), U4.5 (VCC), U5.5 (VCC), U6.17 (VDD), U7.2 (OUT)
BOOT0: R11.2, U1.60 (BOOT0)
D_SWITCH: C20.1, D3.2 (K), J15.1, R14.1, U1.22 (PA6), U5.2 (IN_A)
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C9.2, C10.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, J3.2, J3.4, J4.2 (PM), J6.1, J7.1, J8.3 (GND), J8.5 (GND), J8.9 (GND), J12.4 (GND), J12.5 (Shield_1), J12.6 (Shield_2), J13.2 (PM), J14.2 (PM), J15.2 (PM), R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R27.2, R30.2, R31.2, R32.2, SW1.1, SW2.3, TR1.S, U1.12 (VSSA), U1.18 (VSS_4), U1.63 (VSS_3), U2.13 (GND), U2.24 (GND), U2.25 (GND_PAD), U3.13 (GND), U3.24 (GND), U3.25 (GND_PAD), U4.3 (GND), U5.3 (GND), U6.3 (P3B), U6.4 (HVC/A0), U6.7 (VSS), U6.8 (P1B), U6.16 (A1), U7.1 (GND), X1.2, X1.4
LASER_OUT: J3.1, TR1.D, U1.39 (PC8)
unnamed: R2.2, U2.7 (/RESET), U2.9 (/SLEEP)
unnamed: C7.1, U2.3 (VCP)
unnamed: R5.1, U2.8 (ROSC)
unnamed: C1.1, U2.4 (VREG)
unnamed: R9.1, U2.17 (SENSE1)
unnamed: R7.1, U2.20 (SENSE2)
unnamed: D3.1 (A), R17.1
unnamed: R20.2, U6.1 (P3A), U6.10 (P1A)
unnamed: D1.1 (A), R15.1
unnamed: D2.1 (A), R16.1
unnamed: R26.2, U6.15 (*RESET)
unnamed: C12.1, U3.1 (CP1)
unnamed: C12.2, U3.2 (CP2)
unnamed: C11.2, U2.2 (CP2)
unnamed: C11.1, U2.1 (CP1)
unnamed: D4.2 (K), R27.1
unnamed: D6.2 (K), R31.1
unnamed: R10.1, U3.17 (SENSE1)
unnamed: R8.1, U3.20 (SENSE2)
unnamed: C2.1, U3.4 (VREG)
unnamed: R6.1, U3.8 (ROSC)
unnamed: R4.2, U3.7 (/RESET), U3.9 (/SLEEP)
unnamed: C8.1, U3.3 (VCP)
unnamed: C16.1, U1.47 (VCAP_2)
unnamed: C15.1, U1.31 (VCAP_1)
unnamed: J12.2 (D-), R29.1
unnamed: J12.3 (D+), R28.1
unnamed: U4.4 (OUT), U5.1 (IN_B)
unnamed: R11.1, SW2.2
unnamed: R32.1, U1.28 (PB2)
unnamed: D5.2 (K), R30.1
unnamed: R21.1, TR1.G
unnamed: R21.2, U5.4 (OUT)
OSC32_IN: C27.1, U1.3 (PC14), X2.1
OSC32_OUT: C30.1, U1.4 (PC15), X2.2
OSC_IN: C19.1, U1.5 (PH0/OSC_IN), X1.1
OSC_OUT: C24.1, U1.6 (PH1/OSC_OUT), X1.3
RESET: C21.1, J8.10 (*RST), SW1.2, U1.7 (NRST)
SCL0: R18.2, U1.58 (PB6), U6.5 (SCL)
SDA0: R19.2, U1.59 (PB7), U6.6 (SDA)
TCK: J8.4 (TCK), R24.2, U1.49 (JTCK/SWCLK/PA14)
TDI: J8.8 (TDI), R22.2, U1.50 (JTDI/PA15)
TDO: J8.6 (TDO), R23.2, U1.55 (JTDO/TRACESSW0/PB3)
TMS: J8.2 (TMS), R25.2, U1.46 (JTMS/SWDIO/PA13)
USBM: R29.2, U1.44 (PA11)
USBP: R28.2, U1.45 (PA12)
VBUS: C31.1, C32.1, D5.1 (A), J12.1 (Vbus), U7.3 (IN)
VDDA: C26.1, C29.1, L1.2, U1.13 (VDDA)
V_IN: C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, D4.1 (A), J3.5, J4.1, J6.2 (PM), J7.2 (PM), U2.16 (VBB1), U2.21 (VBB2), U3.16 (VBB1), U3.21 (VBB2)
X_DIR: U1.9 (PC1), U3.14 (DIR)
X_EN: R3.2, U1.10 (PC2), U3.23 (/ENABLE)
X_LIMIT: C17.1, D1.2 (K), J13.1, R13.1, U1.15 (PA1), U4.1 (IN_B)
X_MOT_1A: J9.2, U3.18 (OUT1A)
X_MOT_1B: J9.1, U3.15 (OUT1B)
X_MOT_2A: J9.3, U3.19 (OUT2A)
X_MOT_2B: J9.4, U3.22 (OUT2B)
X_REF: C14.1, J2.1, U3.12 (REF), U6.9 (P1W)
X_STEP: U1.8 (PC0), U3.11 (STEP)
Y_DIR: U1.25 (PC5), U2.14 (DIR)
Y_EN: R1.2, U1.37 (PC6), U2.23 (/ENABLE)
Y_LIMIT: C18.1, D2.2 (K), J14.1, R12.1, U1.20 (PA4), U4.2 (IN_A)
Y_MOT_1A: J10.2, J11.2, U2.18 (OUT1A)
Y_MOT_1B: J10.1, J11.1, U2.15 (OUT1B)
Y_MOT_2A: J10.3, J11.3, U2.19 (OUT2A)
Y_MOT_2B: J10.4, J11.4, U2.22 (OUT2B)
Y_REF: C13.1, J1.1, U2.12 (REF), U6.2 (P3W)
Y_STEP: U1.24 (PC4), U2.11 (STEP)

Notes on the sheet:
Power LEDs
Blue
Green
2k7 resistor chosen to give range of VRef with 0R1 sense resistors for full range of current, to use the maximum current cooling would be required.
Endstops.
Digital Current Limit Control
Y-Axis Stepper Driver
X-Axis Stepper Driver
USB
Laser signal out
Connector
Red

Board: 2 copper layers, 90.0 x 60.0 mm, 99 parts (0 on the bottom side), 72 nets.

File LaserMiniBoard BOM_160803.xlsx:

| Part / Value | Package | Manufacturer | Part No | Circuit Reference | Qty | URL
 | LD1117 | SOT-223 | STMicroelectronics | LD1117S33TR | U7 | 1 | http://www.digikey.jp/product-detail/ja/stmicroelectronics/L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
 | 74VHC1GT08 | TSOP-5 | ON Semiconductor | M74VHC1GT08DTT1G | U4 | 1 | http://www.digikey.jp/product-detail/ja/on-semiconductor/M74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
 | 74HC1G00 | TSOP-5 | ON Semiconductor | MC74HC1G00DTT1G | U5 | 1 | http://www.digikey.jp/product-detail/ja/MC74HC1G00DTT1G/MC74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
 | A4982 | 24-TSSOP | Allegro MicroSystems, LLC | A4982SLPTR | U3,U2 | 2 | http://www.digikey.jp/product-detail/ja/allegro-microsystems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
 | MCP4461 | 20-TSSOP | Microchip Technology | MCP4461-103E/ST | U6 | 1 | http://www.digikey.jp/product-detail/ja/microchip-technology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
 | STM32F205 | 64-LQFP | STMicroelectronics | STM32F205RBT6 | U1 | 1 | http://www.digikey.jp/product-search/ja?keywords=STM32F205RBT6
 | BSH105,215 | SOT-23 | NXP Semiconductors | BSH105 | TR1 | 1 | http://www.digikey.jp/product-detail/ja/nxp-semiconductors/BSH105,215/568-6215-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
 | Tact Switch | DHT-1163S | D.O Electronics Co.,Ltd | DHT-1163S | SW1 | 1 | http://www.seeedstudio.com/depot/images/opl/datasheet/311020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
 | DIP Switch | MS-22D18 | DG De Yi Long Electronics Hardware Limited | MS-22D18 G2 | SW2 | 1 | http://www.seeedstudio.com/depot/images/opl/datasheet/301001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
 | Ferrite bead
 | 220Ω@100MHz, 700mA | 0603 | Laird-Signal Integrity Products | LI0603G221R-10 | L1 | 1 | http://www.digikey.jp/product-detail/ja/LI0603G221R-10/240-2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
 | Crystal
 | 25MHz, 18pF | 5032 | TXC CORPORATION | 7B-25.000MAAJ-T | X1 | 1 | http://www.digikey.jp/product-detail/ja/txc-corporation/7B-2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
 | RTC Crystal
 | 32.768KHz, 7pF | 2-SMD | TXC CORPORATION | 9HT10-32.768KDZY-T | X2 | 1 | http://www.digikey.jp/product-detail/ja/txc-corporation/9HT1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
 | LED
 | 2V, 3mA, Red | 0805 | Any | Any | D1,D2,D3,D5 | 4
 | 2V, 3mA, Green | 0805 | Any | Any | D6 | 1
 | 2V, 3mA, Blue | 0805 | Any | Any | D4 | 1
 | Ceramic Capacitor
 | 10p, Ceramic, 10V, 10% | 0603 | Any | Any | C27,C30 | 2
 | 20p, Ceramic, 10V, 10% | 0603 | Any | Any | C19,C24 | 2
 | 0u1, Ceramic, 10V, 10% | 0603 | Any | Any | C22,C17,C18,C21,C11,C25,C12,C33,C14,C13,C28,C23,C20 | 13
 | 0u22, Ceramic, 10, 10% | 0603 | Any | Any | C1,C2,C10,C9 | 4
 | 2u2, Ceramic, 10V, 10% | 0603 | Any | Any | C15,C16 | 2
 | 1u, Ceramic, 10V, 10% | 0603 | Any | Any | C32 | 1
 | 0u1, Ceramic, 16V, 10% | 0805 | Any | Any | C3,C26,C4,C7,C8 | 5
 | 10u, Ceramic, 10V, 10% | 0805 | Any | Any | C31,C34 | 2
 | Tantalum Capacitor
 | 10uF, 10V, 20% | 1206 | Any | Any | C29 | 1
 | Aluminum Capacitor
 | 100u, 35V, 20% | 6.3 x 7.7mm | Any | Any | C5,C6 | 2 | http://www.digikey.jp/product-detail/ja/UWT1V101MCL1GS/493-2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
 | Resistor
 | 0R, 1/10W | 0603 | Any | Any | R6,R5 | 2
 | 22R, 1/10W, 5% | 0603 | Any | Any | R28,R29 | 2
 | 100R, 1/10W, 5% | 0603 | Any | Any | R21 | 1
 | 470R, 1/10W, 5% | 0603 | Any | Any | R31,R17,R16,R15 | 4
 | 1k, 1/10W, 5% | 0603 | Any | Any | R30 | 1
 | 2k7, 1/10W, 5% | 0603 | Any | Any | R20 | 1
 | 4k7, 1/10W, 5% | 0603 | Any | Any | R27,R18,R19 | 3
 | 10k, 1/10W, 5% | 0603 | Any | Any | R2,R4,R23,R22,R24,R25,R14,R12,R13,R11,R26,R32 | 12
 | 100k, 1/10W, 5% | 0603 | Any | Any | R1,R3 | 2
 | 0R1, 1W, 5% | 1206 | Any | Any | R9,R7,R8,R10 | 4
 | Connector
 | DC Jack Socket | dia. 2.0 | BEST | DC-005 | J4 | 1 | http://www.seeedstudio.com/depot/images/opl/datasheet/341002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
 | USB Type B Connector | USB - B | Any | Any | J12 | 1 | http://www.digikey.jp/product-detail/ja/on-shore-technology-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
 | 2P Connector |  | JST Sales America Inc | B2B-XH-A(LF)(SN) | J6,J7,J13,J14,J15 | 5
 | 4P Connector |  | JST Sales America Inc | B4B-XH-A(LF)(SN) | J9,J10,J11 | 3
 | 5P Connector |  | JST Sales America Inc | B5B-XH-A(LF)(SN) | J3 | 1

## Commit log

2016-08-19 :circus_tent: Added .gitattributes
2016-08-19 データシート追加
2016-09-09 BOM修正
2018-08-08 Create LICENSE
